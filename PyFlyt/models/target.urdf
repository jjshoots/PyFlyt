Commit message: Working setup before training

File: PyFlyt/models/target.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link base_link: geometry visual sphere radius=1
