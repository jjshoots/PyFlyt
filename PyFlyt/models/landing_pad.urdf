Commit message: completed preliminary rocket env

File: PyFlyt/models/landing_pad.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link base_link: geometry collision cylinder length=0.1 radius=2; visual cylinder length=0.1 radius=2
